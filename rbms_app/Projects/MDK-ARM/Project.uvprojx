# Keil uVision project Project.uvprojx, settings and files
target p100_8SBL_230A (5060422::V5.06 update 4 (build 422)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P100 +hex
  AfterMake: c:\keil_v5\ARM\ARMCC\BIN\fromelf.exe --bin "output\%L" --output  "output\P100.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,DEBUG,STM32F107xC,USE_FULL_ASSERT, _RELEASE,MOD_MASTER,_MASTER,__CMSIS_RTOS
  c misc: --diag_suppress 1295
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\Inc;..\..\obs;..\Src\include;..\Src;..\Src\wiznet;..\Src\wiznet\W5500;..\Src\tray\include;..\..\ThirdParty\libModbus;..\..\obs\lib;..\Src\tray;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;.\RTE\_p100_8s_200A_Open107;..\..\Drivers\CMSIS\RTOS\RTX\SRC\ARM;..\..\Drivers\CMSIS\RTOS\RTX\INC;..\..\Drivers\CMSIS\RTOS\RTX\SRC;..\MDK-ARM
  asm define: __CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000010 size 0xffe0
  link misc: --diag_suppress=L6329
  group output
    ./Output/: P100.map
  group configuration File
    ./cfg/: stm32_release.sct
  group Startup
    ./: startup_stm32f105xc.s startup_stm32f107xc.s
  group Driver/stm32f1xx
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c
  group Driver/CMSIS
    ../Src/: system_stm32f4xx.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group obs
    ../../obs/: hsys.c hserial.c hcan.c htimer.c hspi.c hlog.c hos.c heeprom.c hled.c Retarget.c hfet.c hadc.c
  group ApplicationCom
    ../Src/: main.c app_main.c AppQueue.c EEprom_Control.c EEprom_ProcessData.c EEprom_Task.c CAN_DiagComProc.c CAN_Transmit_Task.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f1xx_hal_msp.c stm32f1xx_it.c freertos.c test.c sm.c
    ./: stm32l5xx_STLcpurunKEIL.s
  group Application/TrayBMS
    ../Src/tray/: BMIC_Task.c SubmicProcessData.c oMbMaster.c BMIC_ProcessData.c
  group Application/RBMS
    ../Src/: CUR_PACKV.c Cellbalancing.c RACK_SYS.c SYS_ERR_CHK.c RELAY_CTL.c Soc.c Rack_Task.c Can_DiagRackProc.c GET_EXT_TEMP.c Buzzer_Control.c Can_PcToolProc.c
  group Application/MasterBMS
    ./: Master.c Master_Task.c RS485_Data_Processor.c ExtCom_Transmit_Task.c
  group modbus_master
    ../../ThirdParty/libModbus/: crc16.c modbus.c port_modbus.c
  group RTOS/RTX_OS
    ./lib/: RTX_CM3_IFX.lib
    ./RTE/CMSIS/: RTX_Conf_CM.c
